SRC_URI += "file://0001-vcu-modules.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
