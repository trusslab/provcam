SRC_URI += "file://0001-vcu-ctrl-sw.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
